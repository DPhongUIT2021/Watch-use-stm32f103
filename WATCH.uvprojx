# Keil uVision project WATCH.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WATCH +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Watch_Driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c main.h Buzzer.h
  group Watch_Driver
    ./Watch_Driver/: Watch_GPIO.h Watch_RCC.h Watch_RTC.h Watch_SysTick.h Watch_USART2.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
